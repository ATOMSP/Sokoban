# Keil uVision project demo.uvprojx, settings and files
target Player (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: demo +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: HSE_VALUE=8000000,ARDUINO=111,USE_STDPERIPH_DRIVER,STM32F40_41xxx
  c misc: --gnu
  c include: ..\SrduinoAPI\Platform\CMSIS\Device\ST\STM32F4xx\Include;..\SrduinoAPI\Platform\CMSIS\Include;..\SrduinoAPI\Platform\STM32F4xx_StdPeriph_Driver\inc;..\SrduinoAPI\Platform\Boradcore;..\SrduinoAPI\ArduinoAPI\Inc;..\Library;..\Src\HAL
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Main
    ../Src/: main.cpp config.h
  group Libraries/MillisTaskManager
    ../Library/MillisTaskManager/: MillisTaskManager.cpp
  group Libraries/PageManager
    ../Library/PageManager/: PageManager.cpp
  group Libraries/TonePlayer
    ../Library/TonePlayer/: TonePlayer.cpp
  group Libraries/DecodeJPG
    ../Library/PICTURE/: piclib.cpp tjpgd.cpp
  group Libraries/Adafruit
    ../Library/Adafruit_GFX_Library/: Adafruit_GFX.cpp
    ../Library/Adafruit_ST7789/: Adafruit_ST7789.cpp
  group Libraries/Button
    ../Library/Button/: ButtonEvent.cpp EventType.inc
  group Libraries/Fatfs
    ../Library/Fatfs/src/: ff.c diskio.cpp
  group HAL/Sdfatfs
    ../Src/HAL/: Sdfatfs.cpp
  group HAL/Button
    ../Src/HAL/: Button.cpp
  group APP/Sdfatfs
    ../Src/APP/: APP_Sdfatfs.cpp
  group APP/Music
    ../Src/APP/: APP_Music.cpp
  group Display
    ../Src/Display/: Display.cpp
  group Pages
    ../Src/Display/Pages/: Page_Displate.cpp Page_Master.cpp Page_Level.cpp Page_About.cpp Page_Game.cpp
  group Game
    ../Src/APP/Task/: Game_box.cpp
  group ArduinoAPI
    ../SrduinoAPI/ArduinoAPI/src/: Arduino.c dtostrf.c HardwareSerial.cpp itoa.c Print.cpp SPI.cpp Stream.cpp Tone.cpp Wire.cpp WireBase.cpp WMath.cpp WString.cpp
  group STM32
    ../SrduinoAPI/Platform/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
    ../SrduinoAPI/Platform/Startup/ARM/: startup_stm32f40_41xxx.s
    ../SrduinoAPI/Platform/Boradcore/: system_stm32f4xx.c
  group Core
    ../SrduinoAPI/Platform/src/: adc.c delay.c exti.c flash.c gpio.c pwm.c rng.c timer.c
